# Keil uVision project censor_tm_ADC+RF.uvproj, settings and files
target censor_tm_ADC+RF (MCS-51)
  device: N76S003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x3FF) CLOCK(16000000)
  output: censor_tm_ADC+RF +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Lib_nuvoton;.\Common;.\Code\Head;.\Code\Source;.\Code\Obj;.\LST;.\Output
  group head
    ./Code/Head/: I2C_ADC_HX711.h NRF24L01.h GPIO.h NRF_ex.h Interface_com.h CONFIG.h CENCOR_PROGRAMM.h
  group source
    ./Code/Source/: main.c I2C_ADC_HX711.c NRF24L01.c GPIO.c NRF_ex.c Interface_com.c CENCOR_PROGRAMM.c
  group Common
    ./Common/: Common.c Delay.c
